# Keil uVision project BH-F429.uvprojx, settings and files
target TailControl (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU9250,EMPL_TARGET_STM32F4
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\User\bsp;..\..\User\bsp\bsp_adc;..\..\User\bsp\bsp_key;..\..\User\bsp\bsp_led;..\..\User\bsp\bsp_systick;..\..\User\bsp\bsp_tim_pwm;..\..\User\bsp\bsp_timer;..\..\User\bsp\bsp_uart_fifo;..\..\User\app\steer;..\..\User\app\MPU9250;..\..\User\app\MPU9250\MPL\driver\eMPL;..\..\User\app\MPU9250\MPL\driver\include;..\..\User\app\MPU9250\MPL\driver\stm32L;..\..\User\app\MPU9250\MPL\eMPL-hal;..\..\User\app\MPU9250\MPL\mllite;..\..\User\app\MPU9250\MPL\mpl;..\..\User\app\MPU_IIC;..\..\User\COMMON\VAR_TYPES;..\..\User\COMMON\FILTER;..\..\User\COMMON\MATHS;..\..\User\app\sensor;..\..\User\app\MPU;..\..\User\app;..\..\User\app\detectwater;..\..\User\app\deepthcal;..\..\User\app\MeasureAroundDeepth;..\..\User\app\eyeled;..\..\User\app\control;..\..\User\app\motor
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../../User/: main.c stm32f4xx_it.c
    ../../User/app/steer/: steer.c
    ../../User/app/sensor/: GetSensorData.c
    ../../User/app/: niming.c
    ../../User/app/detectwater/: detect_water.c
    ../../User/app/deepthcal/: deepth.c
    ../../User/app/MeasureAroundDeepth/: MeasureAroundDeepth.c
    ../../User/app/eyeled/: eyeled.c
    ../../User/app/control/: control.c
    ../../User/app/motor/: motor.c
  group BSP
    ../../User/bsp/: bsp.h bsp.c
    ../../User/bsp/bsp_led/: bsp_led.c
    ../../User/bsp/bsp_uart_fifo/: bsp_uart_fifo.c
    ../../User/bsp/bsp_key/: bsp_key.c
    ../../User/bsp/bsp_tim_pwm/: bsp_tim_pwm.c
    ../../User/bsp/bsp_timer/: bsp_timer.c
    ../../User/bsp/bsp_adc/: bsp_adc.c
  group MPL
    ../../User/app/MPU9250/MPL/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../../User/app/MPU9250/MPL/driver/stm32L/: log_stm32.c
    ../../User/app/MPU9250/MPL/eMPL-hal/: eMPL_outputs.c
    ../../User/app/MPU9250/MPL/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ../../User/app/MPU9250/MPL/mpl/: libmpllib.lib
  group MPU9250
    ../../User/app/MPU_IIC/: mpuiic.c
    ../../User/app/MPU9250/: mpu9250.c
  group COMMON
    ../../User/COMMON/FILTER/: filter.c
    ../../User/COMMON/MATHS/: maths.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group DOC
    ../../: 必读说明.txt
